*Heading
** Job name: Job-1 Model name: Model-1
** Generated by: Abaqus/CAE 2021
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=Part-1
*Node
      1,           0.,           0.
      2,           1.,           0.
      3,           2.,           0.
      4,           3.,           0.
      5,           4.,           0.
      6,           5.,           0.
      7,           6.,           0.
      8,           7.,           0.
      9,           8.,           0.
     10,           9.,           0.
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*Element, type=CPS4R
   1,    1,    2,  203,  202
   2,    2,    3,  204,  203
   3,    3,    4,  205,  204
   4,    4,    5,  206,  205
   5,    5,    6,  207,  206
   6,    6,    7,  208,  207
   7,    7,    8,  209,  208
   8,    8,    9,  210,  209
   9,    9,   10,  211,  210
  10,   10,   11,  212,  211
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*Nset, nset=Set-1, generate
    1,  8241,     1
*Elset, elset=Set-1, generate
    1,  8000,     1
** Section: Section-1
*Solid Section, elset=Set-1, material=Material-1
,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=Part-1-1, part=Part-1
*End Instance
**
*End Assembly
**
** MATERIALS
**
*Material, name=Material-1
